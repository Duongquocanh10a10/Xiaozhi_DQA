## sdkconfig.defaults.aclab-esp32s3
```kconfig
CONFIG_IDF_TARGET="esp32s3"
CONFIG_BOARD_TYPE_ACLAB_ESP32S3=y
CONFIG_LCD_ST7735_128X160=y
```
